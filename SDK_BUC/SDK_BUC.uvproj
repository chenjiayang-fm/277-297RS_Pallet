# Keil uVision project SDK_BUC.uvproj, settings and files
target 510PF_BUC_CU_RTC676x (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SN93510 SONiX
  cpu: IRAM(0x200000-0x200FFF) IROM(0x100000-0x107FFF) CLOCK(204000000) CPUTYPE(ARM926EJ-S)
  output: SNCC7XFW
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  AfterMake: .\UTILITY\Merge.bat @L 0x5351 2A000 16 20 2048
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: _510PF_SDK_, RTOS, ASIC, HS_MODE, OP_AP, BUC_CU, RTC676x
  c misc: --c99
  c include: ..\COMMON_SRC\CMSIS;..\COMMON_SRC\CMSIS\rtos;..\COMMON_SRC\I2C;..\COMMON_SRC\CQI2C;..\COMMON_SRC\UART;..\COMMON_SRC\Timer;..\COMMON_SRC\BUF;..\COMMON_SRC\KNL;..\COMMON_SRC\RC;..\COMMON_SRC\OSD;..\COMMON_SRC\LCD;..\COMMON_SRC\INTC;..\COMMON_SRC\SEN;..\COMMON_SRC\SADC;..\COMMON_SRC\BSP;..\COMMON_SRC\WDT;..\COMMON_SRC\PAIR;..\COMMON_SRC\MEDIA;..\COMMON_SRC\AVI;..\COMMON_SRC\MP4;..\COMMON_SRC\CLI;..\COMMON_SRC\CLI\include;..\COMMON_SRC\VCS;..\COMMON_LIB\header;.\SRC\APP;.\SRC\UI;.\SRC\UI\HS;.\SRC\VDO;.\SRC\ADO;.\SRC\Boards;..\COMMON_SRC\APBC;..\COMMON_SRC\SPI;..\COMMON_SRC\Buzzer;..\COMMON_SRC\TRX_IF;..\COMMON_SRC\RTC_EXT;..\COMMON_SRC\GPIO;.\SRC\RTC676x\include;..\COMMON_LIB\header\alaw;..\COMMON_LIB\header\audio32;..\COMMON_LIB\header\audio32\common;..\COMMON_LIB\header\audio32\decoder;..\COMMON_LIB\header\audio32\encoder;..\COMMON_LIB\header\aac\;..\COMMON_LIB\header\aac\aac_enc\libAACenc\include;..\COMMON_LIB\header\aac\aac_enc\libAACenc\src;..\COMMON_LIB\header\aac\aac_enc\libArithCoding\include;..\COMMON_LIB\header\aac\aac_enc\libArithCoding\src;..\COMMON_LIB\header\aac\aac_enc\libFDK\include;..\COMMON_LIB\header\aac\aac_enc\libFDK\src;..\COMMON_LIB\header\aac\aac_enc\libMpegTPEnc\include;..\COMMON_LIB\header\aac\aac_enc\libMpegTPEnc\src;..\COMMON_LIB\header\aac\aac_enc\libPCMutils\include;..\COMMON_LIB\header\aac\aac_enc\libPCMutils\src;..\COMMON_LIB\header\aac\aac_enc\libSACenc\include;..\COMMON_LIB\header\aac\aac_enc\libSACenc\src;..\COMMON_LIB\header\aac\aac_enc\libSBRenc\include;..\COMMON_LIB\header\aac\aac_enc\libSBRenc\src;..\COMMON_LIB\header\aac\aac_enc\libSYS\include;..\COMMON_LIB\header\aac\aac_enc\libSYS\src;..\COMMON_LIB\header\aac\aac_dec\include;..\COMMON_LIB\header\aac\aac_dec\libfaad;..\COMMON_SRC\UART4AI
  asm define: RTOS
  asm include: ..\COMMON_SRC\CMSIS\rtos
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x100000
  scatter file: .\BIN\510PF_BUC_CU_RTC676x.sct
  group CFG
    ./: ReadMe.txt
    ./SRC/Boards/: bsp_select.h
    ../COMMON_SRC/LCD/: LCD_TYPE.h
    ../COMMON_SRC/SEN/: SEN_TYPE.h
    ./SRC/APP/: APP_CFG_SEL.h
  group APP
    ./SRC/APP/: APP_HS.c APP_XUCMD.C APP_UVCUACCMD.C
  group UI
    ./SRC/UI/HS/: UI.c UI_BUCCU[WSVGA].c UI_BUCCU.c UI_UART1.c UI_CMD.c UI_BUCCU[WSVGA]_MENU.c UI_BUCCU[WSVGA]_SUBMENU.c UI_BUCCU[WSVGA]_SUBSUBMENU.c UI_BUCCU[WSVGA]_SUBSUBSUBMENU.c UI_BUCCU[WSVGA]_SUBSUBSUBSUBMENU.c
    ./SRC/UI/: KEY.c PKEY.c AKEY.c GKEY.c PDET.c IR.c TouchPanel.c Trigger.c
  group CMSIS
    ../COMMON_SRC/CMSIS/: main.c system__510PF.c Retarget.c
    ../COMMON_SRC/CMSIS/startup/: startup_510PF.s
    ../COMMON_SRC/CMSIS/rtos/: RTOS.lib
  group System
    ../COMMON_LIB/: PROFILE.lib DDR.lib MMU.lib DMAC.lib RTC.lib VCS.lib EFUSE.lib
    ../COMMON_SRC/INTC/: INTC.c
    ../COMMON_SRC/Timer/: TIMER.c
    ../COMMON_SRC/WDT/: WDT.c
    ../COMMON_SRC/APBC/: APBC.c
    ../COMMON_SRC/RTC_EXT/: RTC_PCF85063A.c
  group BSP
    ../COMMON_SRC/BSP/: BSP.c
    ./SRC/Boards/: BSP_Board.c BSP_Drivers.c
  group Miscellaneous
    ../COMMON_LIB/: CQ.lib SDIO.lib MC.lib
    ../COMMON_SRC/UART/: UART.c
    ../COMMON_SRC/I2C/: I2C.c
    ../COMMON_SRC/CQI2C/: CQI2C.c
    ../COMMON_SRC/SADC/: SADC.c
    ../COMMON_SRC/SPI/: SPI.c
    ../COMMON_SRC/Buzzer/: Buzzer.c
    ../COMMON_SRC/GPIO/: GPIO.c
  group Kernel
    ../COMMON_SRC/KNL/: KNL.c
    ../COMMON_SRC/BUF/: BUF.c
  group BB/RF
    ../COMMON_LIB/: RF_A7130_AP.lib RF_A7130_STA.lib TWC_AP.lib TWC_STA.lib BB_AP_A7130.lib BB_STA_A7130.lib
    ../COMMON_SRC/PAIR/: PAIR.c
  group Storage
    ../COMMON_LIB/: SF.lib SD.lib FS.lib
  group Display
    ../COMMON_SRC/OSD/: OSD.c
    ../COMMON_SRC/LCD/: LCD.c LCD_GPM1125A0.c LCD_TM023KDH03.c LCD_TM024HDH03.c LCD_TM035KDH03.c LCD_SSD2828_Y50019N00N.c LCD_SSD2828.c LCD_SN9C271A.c LCD_TV.c LCD_HSD070IDW1.c LCD_YN700WS008B.c LCD_AHD_TP2915.c LCD_AHD_NVP6021.c LCD_TC358778_Y50019N00N.c
    ../COMMON_LIB/: HDMI.lib
  group CIPHER
    ../COMMON_LIB/: CIPHER.lib
  group Video Process/Codec
    ./SRC/VDO/: VDO.c
    ../COMMON_LIB/: H264.lib IMG.lib JPEG.lib
  group Audio
    ./SRC/ADO/: ADO.c
    ../COMMON_LIB/: ADO.lib ALAW.lib ADO32.lib AACenc.lib AACdec.lib
  group Image Sensor
    ../COMMON_SRC/SEN/: SEN.c OV9732.c OV9750.c AR0330.c H62.c H65.c H66.c H68.c IMX307.c IMX323.c SC2235.c SC2238H.c SC2239.c SC2332.c SC230AI.c RN6752.c TP9950.c GC2053.c GL3004.c GC4653.c PS5268.c GC1084.c GC2083.c
  group Image Quality
    ../COMMON_LIB/: IQ.lib
    ../COMMON_SRC/IQ/: IQ_OPT_SENSOR_RAW.c
  group ISP
    ../COMMON_LIB/: ISP.lib
  group Rate Control
    ../COMMON_SRC/RC/: RC.c
  group FWU
    ../COMMON_LIB/: FWU.lib
  group USBD
    ../COMMON_LIB/: USBD.lib
  group USBH
    ../COMMON_LIB/: USBH.lib
  group CLI
    ../COMMON_SRC/CLI/: CLI.c
    ../COMMON_SRC/CLI/command/: cmd_h264.c cmd_printf.c cmd_vcs.c cmd_i2c.c cmd_isp.c cmd_sf.c cmd_system.c cmd_bb.c cmd_lcd.c cmd_mc.c cmd_ado.c cmd_ddr.c cmd_sd.c cmd_rtc676x.c
  group PLY_REC
    ../COMMON_SRC/MEDIA/: MEDIA.c
    ../COMMON_SRC/MP4/: MP4.c
    ../COMMON_SRC/AVI/: AVI.c
    ../COMMON_LIB/: PLY.lib REC.lib
  group RTC676x
    ./SRC/RTC676x/lib/: RTC676x.lib
    ./SRC/RTC676x/: RTC676x_SPI_src.c RTC676x_TWC.c RTC676x_CTRL.c RTC676x_SPI.c
  group Communication Interface
    ../COMMON_SRC/TRX_IF/: TRX_IF.c
  group S2019
    ../COMMON_LIB/: S2019A.lib
  group UART4AI
    ../COMMON_SRC/UART4AI/: UART4AI.c
target 510PF_BUC_CAM_RTC676x (ARM-ADS)
  device: SN93510 SONiX
  cpu: as above
  output: 510PF_BUC_CAM_RTC676x
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  AfterMake: .\UTILITY\Merge.bat @L 0x5351 2A000 16 20 1600
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: _510PF_SDK_, RTOS, ASIC, HS_MODE, OP_STA, BUC_CAM, RTC676x
  c misc: --c99
  c include: ..\COMMON_SRC\CMSIS;..\COMMON_SRC\CMSIS\rtos;..\COMMON_SRC\I2C;..\COMMON_SRC\CQI2C;..\COMMON_SRC\UART;..\COMMON_SRC\Timer;..\COMMON_SRC\BUF;..\COMMON_SRC\KNL;..\COMMON_SRC\RC;..\COMMON_SRC\OSD;..\COMMON_SRC\LCD;..\COMMON_SRC\INTC;..\COMMON_SRC\SEN;..\COMMON_SRC\SADC;..\COMMON_SRC\BSP;..\COMMON_SRC\WDT;..\COMMON_SRC\PAIR;..\COMMON_SRC\MEDIA;..\COMMON_SRC\AVI;..\COMMON_SRC\MP4;..\COMMON_SRC\CLI;..\COMMON_SRC\CLI\include;..\COMMON_SRC\VCS;..\COMMON_SRC\APBC;..\COMMON_SRC\SPI;..\COMMON_SRC\Buzzer;..\COMMON_SRC\TRX_IF;..\COMMON_SRC\GPIO;..\COMMON_SRC\RTC_EXT;..\COMMON_LIB\header;.\SRC\APP;.\SRC\UI;.\SRC\UI\HS;.\SRC\VDO;.\SRC\ADO;.\SRC\Boards;.\SRC\RTC676x\include;..\COMMON_LIB\header\alaw;..\COMMON_LIB\header\audio32;..\COMMON_LIB\header\audio32\common;..\COMMON_LIB\header\audio32\decoder;..\COMMON_LIB\header\audio32\encoder;..\COMMON_LIB\header\aac\;..\COMMON_LIB\header\aac\aac_enc\libAACenc\include;..\COMMON_LIB\header\aac\aac_enc\libAACenc\src;..\COMMON_LIB\header\aac\aac_enc\libArithCoding\include;..\COMMON_LIB\header\aac\aac_enc\libArithCoding\src;..\COMMON_LIB\header\aac\aac_enc\libFDK\include;..\COMMON_LIB\header\aac\aac_enc\libFDK\src;..\COMMON_LIB\header\aac\aac_enc\libMpegTPEnc\include;..\COMMON_LIB\header\aac\aac_enc\libMpegTPEnc\src;..\COMMON_LIB\header\aac\aac_enc\libPCMutils\include;..\COMMON_LIB\header\aac\aac_enc\libPCMutils\src;..\COMMON_LIB\header\aac\aac_enc\libSACenc\include;..\COMMON_LIB\header\aac\aac_enc\libSACenc\src;..\COMMON_LIB\header\aac\aac_enc\libSBRenc\include;..\COMMON_LIB\header\aac\aac_enc\libSBRenc\src;..\COMMON_LIB\header\aac\aac_enc\libSYS\include;..\COMMON_LIB\header\aac\aac_enc\libSYS\src;..\COMMON_LIB\header\aac\aac_dec\include;..\COMMON_LIB\header\aac\aac_dec\libfaad
  asm define: RTOS
  asm include: ..\COMMON_SRC\CMSIS\rtos
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x100000
  scatter file: .\BIN\510PF_BUC_CAM_RTC676x.sct
target HDW297RS_000000 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SN93510 SONiX
  cpu: as above
  output: SNCC7XFW
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  AfterMake: .\UTILITY\Merge.bat @L 0x5351 2A000 16 20 2048
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: _510PF_SDK_, RTOS, ASIC, HS_MODE, OP_AP, BUC_CU, RTC676x, HDW297RS_000000
  c misc: --c99
  c include: as above
  asm define: RTOS
  asm include: ..\COMMON_SRC\CMSIS\rtos
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x100000
  scatter file: .\BIN\510PF_BUC_CU_RTC676x.sct
target HDW277RS_000000 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SN93510 SONiX
  cpu: as above
  output: SNCC7XFW
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  AfterMake: .\UTILITY\Merge.bat @L 0x5351 2A000 16 20 2048
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: _510PF_SDK_, RTOS, ASIC, HS_MODE, OP_AP, BUC_CU, RTC676x, HDW277RS_000000
  c misc: --c99
  c include: as above
  asm define: RTOS
  asm include: ..\COMMON_SRC\CMSIS\rtos
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x100000
  scatter file: .\BIN\510PF_BUC_CU_RTC676x.sct
target HDW127RS_000000 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SN93510 SONiX
  cpu: as above
  output: SNCC7XFW
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  AfterMake: .\UTILITY\Merge.bat @L 0x5351 2A000 16 20 2048
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: _510PF_SDK_, RTOS, ASIC, HS_MODE, OP_AP, BUC_CU, RTC676x, HDW127RS_000000
  c misc: --c99
  c include: as above
  asm define: RTOS
  asm include: ..\COMMON_SRC\CMSIS\rtos
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x100000
  scatter file: .\BIN\510PF_BUC_CU_RTC676x.sct
